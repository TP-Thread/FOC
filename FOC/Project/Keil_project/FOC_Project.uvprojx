# Keil uVision project FOC_Project.uvprojx, settings and files
target FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4
  c include: ..\..\Drivers\CMSIS;..\..\Drivers\GD32F30x_standard_peripheral\Include;..\..\Core\Inc;..\..\Motor\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ../../Core/Src/: main.c system_gd32f30x.c systick.c gd32f30x_it.c loop.c
  group Motor
    ../../Motor/Src/: drv_motor.c foc_math.c motor_ctrl.c motor_protect.c
  group Drivers
    ../../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ./: startup_gd32f30x_hd.s
software components: CMSIS:CORE 5.5.0
