# IAR project FOC_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xB GD GD32F303xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\Drivers\CMSIS; ..\..\Drivers\GD32F30x_standard_peripheral\Include; ..\..\Core\Inc; ..\..\Motor\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FOC_Project.srec
  ILINK.IlinkOutputFile: FOC_Project.out
  ILINK.IlinkIcfFile: GD32F303xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Core
    ../../Core/Src/: gd32f30x_it.c loop.c main.c system_gd32f30x.c systick.c
  group Drivers
    ../../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Motor
    ../../Motor/Src/: drv_motor.c foc_math.c motor_ctrl.c motor_protect.c
  group Startup
    ./: startup_gd32f30x_hd.s
