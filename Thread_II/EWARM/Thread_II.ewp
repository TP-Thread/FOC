# IAR project Thread_II.ewp, settings and files
configuration Thread_II (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\Bsp\Drv\Inc; ..\Bsp\Prot\Inc; ..\Bsp\Algo\Inc; ..\Bsp\Task\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Thread_II.bin
  ILINK.IlinkOutputFile: Thread_II.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User/Algo
    ../Bsp/Algo/Src/: algo_foc.c algo_pid.c
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Application/User/Drv
    ../Bsp/Drv/Src/: drv_irq.c drv_kth78.c drv_motor.c
  group Application/User/Task
    ../Bsp/Task/Src/: task_loop.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c
